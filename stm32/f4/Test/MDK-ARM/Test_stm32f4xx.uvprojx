# Keil uVision project Test_stm32f4xx.uvprojx, settings and files
target Test (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Test_stm32f4xx
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\f4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group libraryes
    ../../gpio/: stm32f4xx_gpio_config.c
    ../../: stm32f4xx_config.c
  group main
    ./src/: main.c
software components: CMSIS:CORE 5.0.0, Device:Startup 2.6.0
